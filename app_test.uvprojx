# Keil uVision project app_test.uvprojx, settings and files
target STM32F103CBT6 (6180000::V6.18::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app_test +hex
  AfterMake: fromelf.exe --bin --output !L.bin !L
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8002800 size 0x1d800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group my
    ./: main.cpp firmware_header.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
